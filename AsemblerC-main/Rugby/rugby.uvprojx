# Keil uVision project rugby.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rugby
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c init_PORTB.S init_PORTD.S init_PORTE.S init_PORTF.S init_PORTA.S init_PORTC.S display.S visCUATRO.S visDOS.S visTRES.S visUNO.S visCINCO.S delay_ms.S visOCHO.S visSEIS.S visSIETE.S botonesPuntos.S temA.S temB.S botonesTime.S time.S botonStart.S starTime.S finPartido.S visNUEVE.S finPtiempo.S starTimeseg.S
  group inc
    ./: tm4c123gh6pm.h tm4c123gh6pm.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
